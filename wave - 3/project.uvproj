# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: main.c
  group Hardware
    ./: Delay.c OLED.c Key.c AT24C02.c Timer0.c AT24C02.h I2C1.c I2C1.h Key.h XPT2046.c XPT2046.h Timer0.h
